## boards/shields/two_percent_milk/Kconfig.defconfig
```kconfig
if SHIELD_TWO_PERCENT_MILK

config ZMK_KEYBOARD_NAME
	default "MDR Touch"
	
endif
```
